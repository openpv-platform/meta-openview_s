SRC_URI = "git://github.com/posborne/cmsis-svd.git;protocol=https;branch=main"