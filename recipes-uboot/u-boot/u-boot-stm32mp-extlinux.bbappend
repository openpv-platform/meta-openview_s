FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

inherit kernel-arch extlinuxconf-hlio-rcd