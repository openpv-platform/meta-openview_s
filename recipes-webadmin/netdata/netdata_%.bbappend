# disabling netdata
SYSTEMD_AUTO_ENABLE:${PN} = "disable"