DEPENDS:append = " libxshmfence"
