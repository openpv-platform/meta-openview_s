PACKAGECONFIG:class-target:append = " gallium"
