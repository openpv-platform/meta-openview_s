# most of the systat tools can still be run even if service is disabled
SYSTEMD_AUTO_ENABLE = "disable"
