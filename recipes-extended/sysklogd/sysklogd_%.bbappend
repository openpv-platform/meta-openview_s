# we really only need the systemd journal
SYSTEMD_AUTO_ENABLE = "disable"
