EXTRA_OECMAKE += " -DWITH_SERVER=ON"
